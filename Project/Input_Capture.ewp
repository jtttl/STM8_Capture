# IAR project Input_Capture.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208R8 STM8S208R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Input_Capture.hex
  ILINK.IlinkOutputFile: Input_Capture.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    ../FWlib/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_uart1.c
  group USER
    ../USER/: main.c stm8s_it.c sysclock.c tim1_ic.c uart1.c
